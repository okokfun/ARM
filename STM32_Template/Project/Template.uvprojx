# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: ..\User;..\Lib;..\Interrupt;..\Core;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group 1.Boot
    ../Boot/: startup_stm32f40_41xxx.s
  group 2.Doc
    ../Doc/: README.txt
  group 3.Hardware
    ../Hardware/: led.c delay.c sys.c oled.c
  group 4.Interrupt
    ../Interrupt/: stm32f4xx_it.c
  group 5.Lib
    ../Lib/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
  group 9.Core
    ../Core/: system_stm32f4xx.c
  group 10.User
    ../User/: main.c stm32f4xx_conf.h
